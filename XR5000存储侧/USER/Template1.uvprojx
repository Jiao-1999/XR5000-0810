# Keil uVision project Template1.uvprojx, settings and files
target Template1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DS18B20;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\LED;..\HARDWARE\W25Q256;..\HARDWARE\STORAGE;..\HARDWARE\SOFTUART;..\HARDWARE\GB4717_EXPORT;..\HARDWARE\USB_CDC;..\HARDWARE\USB_CDC\STM32_USB_Driver\inc;..\HARDWARE\USB_CDC\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group COER
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/W25Q256/: w25qxx.c
    ../HARDWARE/STORAGE/: bsp_storage_rx.c
    ../HARDWARE/USB_CDC/: usb_cdc.c
    ../HARDWARE/USB_CDC/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../HARDWARE/USB_CDC/STM32_USB_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/GB4717_EXPORT/: gb4717_export.c
