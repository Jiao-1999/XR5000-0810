# Keil uVision project XR5000-H7.uvprojx, settings and files
target XR5000-H7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: XR5000-H7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../HMI_DRIVE;../BSP;../FECbus;../LINKAGE;../LINKAGE/FIRE_ZONE;../STORAGE;..\LINKAGE\FIRE_ZONE
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: .\XR5000-H7\XR5000-H7.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c iwdg.c mdma.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HMI_DRIVE
    ../HMI_DRIVE/: cmd_queue.c hmi_driver.c hmi_user_uart.c cmd_process.c
  group BSP
    ../BSP/: bsp_screen.c bsp_itcallback.c bsp_debug.c bsp_test_inject.c system.c bsp_access_control.c 24c04.c w25qxx.c bsp_mbus.c bsp_mbus_control.c bsp_spray_output_policy.c bsp_device_registry.c bsp_device_registration.c bsp_device_threshold.c bsp_rs485_01.c bsp_ig3302.c bsp_ig3302_policy.c bsp_rs485_detect.c bsp_relay.c bsp_adc.c bsp_key.c bsp_rtc.c bsp_aht20.c bsp_logic_set.c bsp_bms.c bsp_linkage_ctrl.c bsp_super.c bsp_internal_board.c bsp_save_ctrl.c bsp_history_filter.c bsp_device_disable.c bsp_device_alias.c bsp_device_alias_hmi.c bsp_station.c bsp_ctrl_bus.c bsp_fdcan1.c bsp_can_monitor.c bsp_fdcan2.c bsp_circuit_ctrl.c bsp_password.lib
  group LINKAGE
    ../LINKAGE/: bsp_logic_expr.c bsp_logic_dev.c bsp_logic_engine.c bsp_logic_screen.c
    ../LINKAGE/FIRE_ZONE/: bsp_fire_zone.c bsp_fire_zone_screen.c
    ../STORAGE/: bsp_storage_test.c
  group STORAGE
    ../STORAGE/: bsp_storage_tx.c bsp_storage_event.c
  group FECbus
    ../FECbus/: bsp_fecbus.c bsp_fecbus_report.c bsp_fecbus_rx.c
software components: CMSIS:CORE 5.2.0
